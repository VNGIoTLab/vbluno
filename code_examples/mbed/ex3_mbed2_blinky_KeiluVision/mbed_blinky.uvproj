# Keil uVision project mbed_blinky.uvproj, settings and files
target mbed_blinky (ARM-ADS)
  device: nRF51822_xxAC Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: mbed_blinky +hex
  AfterMake: fromelf --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1
  c define: __CORTEX_M0, TARGET_MCU_NRF51_16K, TARGET_MCU_NRF51822, TARGET_NRF51822_MKIT, NRF51, TARGET_CORTEX_M, TARGET_LIKE_MBED, TARGET_NRF51822, ARM_MATH_CM0, TOOLCHAIN_ARM_STD, __MBED__=1, TARGET_NORDIC, MBED_BUILD_TIMESTAMP=1467714347, TARGET_MCU_NRF51, TARGET_MCU_NORDIC_16K, TARGET_M0, TARGET_MCU_NRF51_16K_S130, TOOLCHAIN_ARM, TARGET_LIKE_CORTEX_M0, __ASSERT_MSG
  c misc: --gnu --no_rtti --restrict --apcs=interwork -c -O3 -I"C:/Program Files/ARM/armcc_4.1_791/include" --split_sections --multibyte_chars --brief_diagnostics -D__ASSERT_MSG --no_depend_system_headers --md --cpu=Cortex-M0 -Otime --gnu --brief_diagnostics --apcs=interwork --cpu=Cortex-M0
  c include: .; mbed; mbed/TARGET_NRF51822; mbed/TARGET_NRF51822/TARGET_NORDIC; mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822; mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib; mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/nordic_sdk; mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/nordic_sdk/components; mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/nordic_sdk/components/libraries; mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/nordic_sdk/components/libraries/crc16; mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/nordic_sdk/components/libraries/scheduler; mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/nordic_sdk/components/libraries/util; mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/s110_nrf51822_8_0_0; mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/s130_nrf51822_1_0_0; mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/TARGET_NRF51822_MKIT; mbed/TARGET_NRF51822/TOOLCHAIN_ARM_STD
  asm define: as above
  asm misc: --brief_diagnostics -I"C:/Program Files/ARM/armcc_4.1_791/include" --apcs=interwork --cpu=Cortex-M0
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: mbed/TARGET_NRF51822/TOOLCHAIN_ARM_STD/nRF51822.sct
  group Include Files
    mbed/: AnalogIn.h analogin_api.h AnalogOut.h analogout_api.h buffer.h BusIn.h BusInOut.h BusOut.h CallChain.h CAN.h can_api.h can_helper.h CircularBuffer.h CThunk.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h dma_api.h Ethernet.h ethernet_api.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FunctionPointer.h gpio_api.h gpio_irq_api.h I2C.h i2c_api.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h lp_ticker_api.h mbed.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h pinmap.h platform.h port_api.h PortIn.h PortInOut.h PortOut.h PwmOut.h pwmout_api.h RawSerial.h rtc_api.h rtc_time.h semihost_api.h Serial.h serial_api.h SerialBase.h sleep_api.h SPI.h spi_api.h SPISlave.h Stream.h Ticker.h ticker_api.h Timeout.h Timer.h TimerEvent.h toolchain.h Transaction.h us_ticker_api.h wait_api.h
    mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/nordic_sdk/components/libraries/util/: app_error.h app_util.h
    mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/nordic_sdk/components/libraries/scheduler/: app_scheduler.h
    mbed/TARGET_NRF51822/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis.h cmsis_nvic.h compiler_abstraction.h core_ca9.h core_ca_mmu.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_sc000.h core_sc300.h nrf.h nrf51.h nrf51_bitfields.h nrf_delay.h system_nrf51.h
    mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/nordic_sdk/components/libraries/crc16/: crc16.h
    mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/TARGET_NRF51822_MKIT/: device.h PinNames.h
    mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/: gpio_object.h objects.h PeripheralNames.h PortNames.h twi_config.h twi_master.h
  group Source Files
    mbed/TARGET_NRF51822/TOOLCHAIN_ARM_STD/: board.o cmsis_nvic.o mbed.ar retarget.o startup_nRF51822.o sys.o system_nrf51.o
    ./: main.cpp
