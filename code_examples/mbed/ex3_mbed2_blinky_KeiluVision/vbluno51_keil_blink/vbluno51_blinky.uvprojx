# Keil uVision project vbluno51_blinky.uvprojx, settings and files
target vbluno51_blinky (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.7.1
  cpu: CPUTYPE("Cortex-M0")
  output: vbluno51_blinky
  c flags: Optim=1 uC99=1
  c misc: -DDEVICE_RTC=1 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTARGET_MCU_NRF51822 -DTARGET_NRF5 --split_sections -DTARGET_MCU_NRF51822_UNIFIED -DTARGET_MCU_NRF51_32K -D__ASSERT_MSG -DTARGET_MCU_NORDIC_32K -DTARGET_NRF51822 --no_rtti -DS130 -DDEVICE_PORTINOUT=1 -DTARGET_MCU_NRF51_32K_UNIFIED -DDEVICE_SERIAL_FC=1 -DSOFTDEVICE_PRESENT -DDEVICE_I2C_ASYNCH=1 -DTARGET_FF_ARDUINO -c -DTARGET_NORDIC -DDEVICE_SPISLAVE=1 -DDEVICE_PORTOUT=1 -DMBED_BUILD_TIMESTAMP=1495118586.63 -DTARGET_RELEASE -DTARGET_LIKE_MBED -DTARGET_MCU_NRF51_UNIFIED -DTARGET_LIKE_CORTEX_M0 -DARM_MATH_CM0 -DDEVICE_ANALOGIN=1 -DTARGET_NRF51_DK -DDEVICE_PORTIN=1 -DTARGET_CORTEX_M -DDEVICE_ERROR_PATTERN=1 --cpu=Cortex-M0 -DDEVICE_I2C=1 -DBLE_STACK_SUPPORT_REQD --preinclude=mbed_config.h -DDEVICE_LOWPOWERTIMER=1 -DTOOLCHAIN_ARM -D__CORTEX_M0 -DNRF51 -DTOOLCHAIN_ARM_STD --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED --md -DDEVICE_PWMOUT=1 -DDEVICE_SERIAL_ASYNCH=1 --gnu -DTARGET_MCU_NRF51 --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DDEVICE_SERIAL=1 -DTARGET_M0 -DDEVICE_INTERRUPTIN=1 -D__CMSIS_RTOS -DDEVICE_SPI_ASYNCH=1 -DFEATURE_BLE=1 -D__MBED_CMSIS_RTOS_CM
  c include: .; mbed/.; mbed/TARGET_NRF51_DK; mbed/TARGET_NRF51_DK/TARGET_NORDIC; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/TARGET_NRF51_DK; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/device; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/sdk; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/sdk/drivers_nrf; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/sdk/drivers_nrf/adc; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/sdk/softdevice; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/sdk/softdevice/s130; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/sdk/softdevice/s130/headers; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/sdk/softdevice/s130/headers/nrf51; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/sdk/softdevice/s130/hex; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/ble; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/ble/ble_advertising; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/ble/ble_db_discovery; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/ble/ble_debug_assert_handler; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/ble/ble_dtm; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/ble/ble_error_log; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/ble/ble_racp; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/ble/ble_radio_notification; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/ble/ble_services; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/ble/ble_services/ble_dfu; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/ble/common; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/ble/device_manager; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/ble/device_manager/config; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/ble/peer_manager; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/device; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/ble_flash; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/clock; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/common; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/config; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/delay; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/gpiote; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/hal; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/ppi; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/pstorage; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/pstorage/config; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/spi_master; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/spi_slave; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/timer; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/libraries; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/bootloader_dfu; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/bootloader_dfu/hci_transport; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/crc16; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/experimental_section_vars; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/fds; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/fds/config; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/fstorage; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/fstorage/config; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/hci; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/hci/config; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/pwm; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/scheduler; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/trace; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/util; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/softdevice; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/softdevice/common; mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/softdevice/common/softdevice_handler; mbed/TARGET_NRF51_DK/TOOLCHAIN_ARM_STD; mbed/drivers; mbed/hal; mbed/platform
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CORTEX_M0,-DTARGET_MCU_NRF51822,-DTARGET_MCU_NORDIC_32K,-DSOFTDEVICE_PRESENT,-DNRF51,-DTARGET_NRF51822,-DARM_MATH_CM0,-D__MBED_CMSIS_RTOS_CM,-DS130,-DBLE_STACK_SUPPORT_REQD,-D__CMSIS_RTOS,-DTARGET_MCU_NRF51_32K
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed/TARGET_NRF51_DK/TOOLCHAIN_ARM_STD/nRF51822.sct
  group mbed
    mbed/drivers/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FlashIAP.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h Serial.h SerialBase.h SPI.h SPISlave.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h
    mbed/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h dma_api.h Driver_Common.h Driver_Storage.h emac_api.h ethernet_api.h flash_api.h flash_data.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
    mbed/TARGET_NRF51_DK/TOOLCHAIN_ARM_STD/: analogin_api.o app_error.o app_error_weak.o app_pwm.o app_scheduler.o app_trace.o app_util_platform.o ble_advdata.o ble_advertising.o ble_conn_state.o ble_db_discovery.o ble_debug_assert_handler.o ble_dfu.o ble_dtm.o ble_flash.o ble_racp.o ble_radio_notification.o ble_srv_common.o bootloader_util.o cmsis_nvic.o crc16.o device_manager_peripheral.o dfu_app_handler.o dfu_init_template.o fds.o fstorage.o fstorage_nosd.o gatt_cache_manager.o gattc_cache_manager.o gatts_cache_manager.o gpio_api.o hci_mem_pool.o i2c_api.o id_manager.o lp_ticker.o mbed.ar mbed_board.o mbed_retarget.o nordic_critical.o nrf_adc.o nrf_assert.o nrf_delay.o nrf_drv_adc.o nrf_drv_clock.o nrf_drv_common.o nrf_drv_gpiote.o nrf_drv_ppi.o nrf_drv_spi.o nrf_drv_spis.o nrf_drv_timer.o nrf_ecb.o nrf_log.o nrf_nvmc.o nrf_saadc.o peer_data.o peer_data_storage.o peer_database.o peer_id.o peer_manager.o pinmap.o pm_buffer.o pm_mutex.o port_api.o pstorage.o pwmout_api.o reloc_vector_table.o rtc_api.o sdk_mapped_flags.o security_dispatcher.o security_manager.o serial_api.o sleep.o softdevice_handler.o softdevice_handler_appsh.o spi_api.o startup_nRF51822.o sys.o system_nrf51.o us_ticker.o
    mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/softdevice/common/softdevice_handler/: ant_stack_handler_types.h app_ram_base.h ble_stack_handler_types.h softdevice_handler.h softdevice_handler_appsh.h
    mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/util/: app_error.h app_error_weak.h app_util.h app_util_bds.h app_util_platform.h common.h nordic_common.h nrf_assert.h nrf_log.h sdk_common.h sdk_errors.h sdk_macros.h sdk_mapped_flags.h sdk_os.h sdk_resources.h
    mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/pwm/: app_pwm.h
    mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/scheduler/: app_scheduler.h
    mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/trace/: app_trace.h
    mbed/TARGET_NRF51_DK/: arm_common_tables.h arm_const_structs.h arm_math.h core_ca9.h core_ca_mmu.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSecureAccess.h core_cmSimd.h core_sc000.h core_sc300.h
    mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/ble/common/: ble_advdata.h ble_conn_params.h ble_conn_state.h ble_date_time.h ble_gatt_db.h ble_sensor_location.h ble_srv_common.h
    mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/ble/ble_advertising/: ble_advertising.h
    mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/ble/ble_db_discovery/: ble_db_discovery.h
    mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/ble/ble_debug_assert_handler/: ble_debug_assert_handler.h
    mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/ble/ble_services/ble_dfu/: ble_dfu.h
    mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/ble/ble_dtm/: ble_dtm.h
    mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/ble/ble_error_log/: ble_error_log.h
    mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/ble_flash/: ble_flash.h
    mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/ble/ble_racp/: ble_racp.h
    mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/ble/ble_radio_notification/: ble_radio_notification.h
    mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/bootloader_dfu/: bootloader.h bootloader_settings.h bootloader_types.h bootloader_util.h dfu.h dfu_app_handler.h dfu_bank_internal.h dfu_ble_svc.h dfu_ble_svc_internal.h dfu_init.h dfu_transport.h dfu_types.h
    mbed/platform/: Callback.h CallChain.h CircularBuffer.h critical.h CThunk.h FunctionPointer.h mbed_application.h mbed_assert.h mbed_critical.h mbed_debug.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_preprocessor.h mbed_retarget.h mbed_rtc_time.h mbed_semihost_api.h mbed_sleep.h mbed_stats.h mbed_toolchain.h mbed_wait_api.h platform.h PlatformMutex.h rtc_time.h semihost_api.h SingletonPtr.h sleep.h toolchain.h Transaction.h wait_api.h
    mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/device/: cmsis.h cmsis_nvic.h system_nrf51.h
    mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/: common_rtc.h gpio_object.h irq_handlers_hw.h nrf5x_lf_clk_helper.h objects.h
    mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/device/: compiler_abstraction.h nrf.h nrf51.h nrf51_bitfields.h nrf51_deprecated.h nrf51_to_nrf52.h nrf52.h nrf52_bitfields.h nrf52_name_change.h
    mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/crc16/: crc16.h
    mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/TARGET_NRF51_DK/: device.h PinNames.h
    mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/ble/device_manager/: device_manager.h
    mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/ble/device_manager/config/: device_manager_cnfg.h
    mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/fds/: fds.h fds_internal_defs.h
    mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/fds/config/: fds_config.h
    mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/fstorage/: fstorage.h fstorage_internal_defs.h
    mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/fstorage/config/: fstorage_config.h
    mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/ble/peer_manager/: gatt_cache_manager.h gattc_cache_manager.h gatts_cache_manager.h id_manager.h peer_data.h peer_data_storage.h peer_database.h peer_id.h peer_manager.h peer_manager_internal.h peer_manager_types.h pm_buffer.h pm_mutex.h security_dispatcher.h security_manager.h
    mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/hci/: hci_mem_pool.h
    mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/bootloader_dfu/hci_transport/: hci_mem_pool_internal.h hci_transport_config.h
    mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/hci/config/: hci_mem_pool_internal.h hci_transport_config.h
    mbed/: mbed.h
    mbed/TARGET_NRF51_DK/TARGET_NORDIC/: mbed_rtx.h
    mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/hal/: nrf_adc.h nrf_clock.h nrf_ecb.h nrf_gpio.h nrf_gpiote.h nrf_nvmc.h nrf_pdm.h nrf_ppi.h nrf_pwm.h nrf_rtc.h nrf_saadc.h nrf_spi.h nrf_spim.h nrf_spis.h nrf_temp.h nrf_timer.h nrf_twi.h nrf_uart.h nrf_wdt.h
    mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/sdk/softdevice/s130/headers/: nrf_ble.h nrf_ble_err.h nrf_ble_gap.h nrf_ble_gatt.h nrf_ble_gattc.h nrf_ble_gatts.h nrf_ble_hci.h nrf_ble_l2cap.h nrf_ble_ranges.h nrf_ble_types.h nrf_error.h nrf_error_sdm.h nrf_error_soc.h nrf_nvic.h nrf_sd_def.h nrf_sdm.h nrf_soc.h nrf_svc.h
    mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/delay/: nrf_delay.h
    mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/sdk/drivers_nrf/adc/: nrf_drv_adc.h
    mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/clock/: nrf_drv_clock.h
    mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/common/: nrf_drv_common.h
    mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/sdk/: nrf_drv_config.h
    mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/config/: nrf_drv_config_validation.h
    mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/gpiote/: nrf_drv_gpiote.h
    mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/ppi/: nrf_drv_ppi.h
    mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/spi_master/: nrf_drv_spi.h
    mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/spi_slave/: nrf_drv_spis.h
    mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/timer/: nrf_drv_timer.h
    mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/sdk/softdevice/s130/headers/nrf51/: nrf_mbr.h
    mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/: PeripheralNames.h PortNames.h
    mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/pstorage/: pstorage.h
    mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/pstorage/config/: pstorage_platform.h
    mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/experimental_section_vars/: section_vars.h
  group vbluno51_blinky
    ./: main.cpp mbed_config.h
